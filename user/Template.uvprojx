# Keil uVision project Template.uvprojx, settings and files
target HKUST_RM2017_Mainboard (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c main.c system_stm32f4xx.c external_control.c gimbal_control.c PID_s.c power_control.c chassis_control.c customized_function.c power_control.h gimbal_control.h global_variable.h customized_function.h external_control.h PID_s.h BSP_TIM.c TIM_handler.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../fwlib/src/: stm32f4xx_rcc.c
  group SYSTEM
    ./: buzzer.c gpio.c ticks.c pwm.c timer.c button.c led.c buzzer_song.c 1.8 TFT_display.c flash.c yaw_gyro.c adc.c encoder.c pneumatic.c can1.c can2.c canBusProcess.c Dbus.c judge.c data_monitor.c Driver_Encoder.c Driver_Gun.c
